# IAR project transmitter.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32L152RC ST STM32L152RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L152xC
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc; ../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Include; ../Drivers/CMSIS/Device/ST/STM32L1xx/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: transmitter.srec
  ILINK.IlinkOutputFile: transmitter.out
  ILINK.IlinkIcfFile: stm32l152xc_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/iar/: startup_stm32l152xc.s
  group Application/User
    ../Src/: gpio.c lcd.c lora.c main_tx.c spi.c stm32l1xx_hal_msp.c stm32l1xx_it.c system_util.c
  group Drivers/BSP
    ../Src/: stm32l152c_discovery.c stm32l152c_discovery_glass_lcd.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L1xx/Source/Templates/: system_stm32l1xx.c
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_dma.c stm32l1xx_hal_flash.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_gpio.c stm32l1xx_hal_lcd.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_tim.c stm32l1xx_hal_tim_ex.c
