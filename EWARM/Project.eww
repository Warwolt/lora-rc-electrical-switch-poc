<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\receiver.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\transmitter.ewp</path>
    </project>
    <batchBuild />
</workspace>
